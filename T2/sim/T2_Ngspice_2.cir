*voltage divider netlist
.options savecurrents
.INCLUDE ../doc/ngspice.log
