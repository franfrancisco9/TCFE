*voltage divider netlist
.options savecurrents
